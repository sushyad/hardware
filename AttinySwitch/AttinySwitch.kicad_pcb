# Repository sushyad/hardware

## KiCad design AttinySwitch/AttinySwitch.kicad_pcb

Parts:
D1: LED
IC1: ATTINY84-P; DIP14
K1: CONN_3
P1: CONN_4X2
P2: PWR/LOAD
P3: CONN_2
P4: SWITCH
Q1: PN2222A; TO92
R1, R4: 220
R2: 10K
R3: 1K
R6: 100K
U1: AQH3223

Connections:
/+5v: K1.1, Q1.3 (C), R3.1
/GND: D1.2 (K), IC1.14 (GND), K1.2 (PM), P1.1, R2.1, R6.1
unnamed: IC1.2 ((PCINT8/CLKI/XTAL1)PB0), R1.1
unnamed: K1.3, R1.2
unnamed: D1.1 (A), R4.2
unnamed: IC1.6 ((PCINT7/ICP/OC0B/ADC7)PA7), P1.7
unnamed: IC1.7 ((PCINT6/SDA/DI/MOSI/OC1A/ADC6)PA6), P1.4
unnamed: IC1.8 ((PCINT5/DO/MISO/OC1B/ADC5)PA5), P1.6
unnamed: IC1.9 ((PCINT4/USCK/SCL/T1/ADC4)PA4), P1.3
unnamed: IC1.10 ((PCINT3/T0/ADC3)PA3), P1.2
unnamed: Q1.1 (B), R2.2, R3.2, U1.4 (-)
unnamed: IC1.12 ((PCINT1/AIN0/ADC1)PA1), R4.1, U1.2 (+)
unnamed: IC1.5 ((PCINT10/CKOUT/OC0A/INT0)PB2), P4.2 (PM), R6.2
unnamed: P2.2, U1.8 (S2)
unnamed: IC1.1 (VCC), P1.8, P4.1, Q1.2 (E)
unnamed: P2.4, P3.2 (PM)
unnamed: P2.3, P3.1
unnamed: P2.1, U1.6 (S1)

Board: 2 copper layers, 41.9 x 35.6 mm, 14 parts (0 on the bottom side), 18 nets.

## Commit log

2014-02-17 Attiny based switch Kicad files
2014-02-18 Added voltage regulator and SSR
2014-02-18 kicad libraries
2014-02-21 Added switch and wireless interrupt to Pin 5 (INT 0)
2014-03-09 Added push button to interrupt pin
2014-03-15 Version sent to OSH for fab on 03/08/2014
